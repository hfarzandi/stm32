<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MSD_103ZE.ewp</path>
  </project>
  <batchBuild />
</workspace>
